# Keil uVision project BH-F767.uvprojx, settings and files
target GPS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SDMMC +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include;..\..\Libraries\STM32F7xx_HAL_Driver\Inc;..\..\User;..\..\User\FATFS;..\..\User\nmea_decode\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../User/: stm32f7xx_hal_conf.h
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group USER
    ../../User/: main.c stm32f7xx_it.c nema_decode_test.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/key/: bsp_key.c
    ../../User/sdmmc/: bsp_sdmmc_sd.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/gps/: gps_config.c
  group FatFs
    ../../User/FATFS/: diskio.c ff.c ff_gen_drv.c sd_diskio.c
    ../../User/FATFS/option/: cc936.c
  group nmealib
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group DOC
    ../../: 必读说明.txt
